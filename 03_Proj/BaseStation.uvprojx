# Keil uVision project BaseStation.uvprojx, settings and files
target BaseStation (5060960::V5.06 update 7 (build 960)::.\ARM_Complier_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BaseStation
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\01_Src\App\Include;..\01_Src\BSP\Include;..\01_Src\Com\Include;..\01_Src\Deca\decaDriver\Include;..\01_Src\Deca\decaPlatform\Include;..\01_Src\Drv\Include;..\01_Src\Middleware\MultiButton\Include;..\01_Src\Middleware\MultiTimer\Include;..\02_Lib;..\02_Lib\CMSIS\CM3\CoreSupport;..\02_Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\02_Lib\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../01_Src/App/Source/: app_main.c app_stm32f10x_it.c app_dwm1000.c app_mcu.c
  group Bsp
    ../01_Src/BSP/Source/: bsp_Bee.c bsp_DWM1000.c bsp_Led.c bsp_W25QXX.c
  group Com
    ../01_Src/Com/Source/: com_BufferManage.c com_LoopList.c Com_MultiButton.c Com_MultiTimer.c
  group Drv
    ../01_Src/Drv/Source/: drv_Mcu.c drv_Rcc.c drv_Gpio.c drv_Uart.c drv_Timer.c drv_Spi.c drv_I2c.c drv_Iwdg.c
  group DecaDrviver/UWB
    ../01_Src/Deca/decaDriver/Source/: deca_device.c deca_params_init.c deca_range_tables.c
    ../01_Src/Deca/decaPlatform/Source/: deca_mutex.c deca_sleep.c deca_spi.c
  group ST/Lib
    ../02_Lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../02_Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../02_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../02_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
